# Keil uVision project uart_register_F407VGT6.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_register_F407VGT6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\User;.\Start;.\Hardware\LED;E:\Keil\ARM\CMSIS\5.9.0\CMSIS\Core\Include;.\Hardware\KEY;.\Hardware\USART
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: core_cm4.h startup_stm32f407xx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group User
    ./User/: main.c delay.c
  group Hardware/LED
    ./Hardware/LED/: led.c
  group Hardware/KEY
    ./Hardware/KEY/: key.c
  group Hardware/USART
    ./Hardware/USART/: usart.c
